# Keil uVision project netGateMaster.uvprojx, settings and files
target Zigbee(cc2530)&WIFI(esp8266)网关主机 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: netGateMaster +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Usr;.\member_dataTrans;.\usr_Method;.\member_GUI;.\member_GUI\hardware_Driver\lcd_ili9341_driver;.\member_GUI\hardware_Driver\touch_ft6236_driver;.\member_GUI\emwin_config;.\member_GUI\emwin_lib;.\member_GUI\gui_usrCustom;.\member_GUI\emwin_Include\inc_version5.42;.\member_GUI\emwin_DEMO\demo_version5.20;.\member_GUI\emwin_DEMO\demo_version5.30
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 用户文件
    ./Usr/: app_Main.c delay.c
  group 数据传输
    ./member_dataTrans/: UART_dataTransfer.c
  group 人机交互业务
    ./member_GUI/gui_usrCustom/: bussiness_userInterface.c
  group 人机交互硬件驱动
    ./member_GUI/hardware_Driver/lcd_ili9341_driver/: ili9341_driver.c LCDTFT_driver.c
    ./member_GUI/hardware_Driver/touch_ft6236_driver/: ft6236_driver.c
  group 人机交互配置
    ./member_GUI/emwin_config/: LCDConf.c GUIConf.c GUI_X_Touch_Analog.c GUI_X_CMSIS_RTOS.c
    ./member_GUI/emwin_lib/: GUI_CM3_L_version5.42.lib
  group emwin_DEMO
    ./member_GUI/emwin_DEMO/demo_version5.30/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:USART 2.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
